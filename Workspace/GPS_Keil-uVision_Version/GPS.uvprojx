# Keil uVision project GPS.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./: main.c main.h APP.c APP.h
  group HAL
    ./: CLCD_config.h CLCD_interface.h CLCD_private.h CLCD_program.c LED_config.h LED_interface.h LED_private.h LED_program.c GPS_config.h GPS_interface.h GPS_private.h GPS_program.c
  group MCAL
    ./: GPIO_config.h GPIO_interface.h GPIO_private.h GPIO_program.c STK_config.h STK_interface.h STK_private.h STK_program.c UART_config.h UART_interface.h UART_private.h UART_program.c
  group LIB
    ./: BIT_MATH.h STD_TYPES.h tm4c123gh6pm.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
