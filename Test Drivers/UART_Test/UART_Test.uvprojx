# Keil uVision project UART_Test.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UART_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: BIT_MATH.h DIO_config.h DIO_interface.h DIO_private.h DIO_program.c main.c STD_TYPES.h tm4c123gh6pm.h UART_config.h UART_interface.h UART_private.h UART_program.c LED_config.h LED_interface.h LED_private.h LED_program.c STK_config.h STK_interface.h STK_private.h STK_program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
